<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040\s132\iar\flash_fstorage_s132_pca10040.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pca10040\blank\iar\flash_fstorage_blank_pca10040.ewp</path>
    </project>
    <batchBuild />
</workspace>
